
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://interfaces \
            file://setup-dhc6.sh \
           "
